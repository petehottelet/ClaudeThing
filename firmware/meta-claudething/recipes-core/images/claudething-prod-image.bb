SUMMARY = "ClaudeThing production image"
DESCRIPTION = "ClaudeThing dashboard firmware with the local web application and managed Chromium kiosk."
LICENSE = "MIT"

require claudething-image-base.inc

IMAGE_OVERHEAD_FACTOR = "1.0"
IMAGE_ROOTFS_EXTRA_SPACE = "4096"
